## buildroot/package/accelerator_test/Config.in
```kconfig
config BR2_PACKAGE_ACCELERATOR_TEST
	bool "accelerator_test"
	help
	  1D-conv accelerator test
```
